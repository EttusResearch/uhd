options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    copyright: Copyright 2024 Ettus Research, an NI Brand
    description: Showcases the RFNoC Gain block in a GNU Radio flow graph.
    generate_options: qt_gui
    id: rfnoc_rx_gain
    output_language: python
    title: RFNoC Gain Example
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    start: '0'
    step: 1e6
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2288e6
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: args
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Args
    type: str
    value: addr=192.168.178.52
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '.1'
    ymin: '-.1'
  states: {}
- name: radio_rate
  id: parameter
  parameters:
    label: Radio Sampling Rate
    short_id: R
    type: eng_float
    value: 245.76e6
  states: {}
- name: rfnoc_gain_gain_generic_0
  id: rfnoc_gain_gain_generic
  parameters:
    device_select: '-1'
    gain: '10'
    instance_index: '-1'
  states: {state: disabled}
- name: rfnoc_gain_gain_native_0
  id: rfnoc_gain_gain_native
  parameters:
    device_select: '-1'
    gain: '100'
    instance_index: '-1'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: samp_rate
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    iq_balance0: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}

connections:
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: rfnoc_gain_gain_generic_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: rfnoc_gain_gain_native_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: rfnoc_gain_gain_generic_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: rfnoc_gain_gain_native_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-799-g2a8b58ca
